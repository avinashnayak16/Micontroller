LDI R20,HIGH(RAMEND)
OUT SPH,R20
LDI R20,LOW(RAMEND)
OUT SPL,R20

LDI R16,0X20
LDI R17,0X00
SBI DDRB,5
OUT PORTB,R17

BEGIN: RCALL DELAY
       EOR R17,R16
	   OUT PORTB,R17
	   RJMP BEGIN

DELAY: LDI R20,0XE0
       OUT TCNT1H,R20
	   LDI R20,0XC0
       OUT TCNT1L,R20
	   LDI R20,0X00
       OUT TCCR1A,R20
	   LDI R20,0X01
       OUT TCCR1B,R20

AGAIN: IN R20,TIFR
       SBRS R20,TOV1
	   RJMP AGAIN
	   LDI R20,00
	   OUT TCCR1A,R20
	   OUT TCCR1B,R20
	   LDI R20,(1<<TOV1)
	   OUT TIFR,R20
	   RET;